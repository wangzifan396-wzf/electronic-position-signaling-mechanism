# Keil uVision project Fire_F103.uvprojx, settings and files
target VL53L0X_Experiment (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Fire_F103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --no_multibyte_chars
  c include: ..\Libraries\CMSIS\Device\ST\STM32F1xx\Include;..\Libraries\CMSIS\Include;..\Libraries\STM32F1xx_HAL_Driver\Inc;..\User;..\APP;..\User\vl53l0x\Api\core\inc;..\User\vl53l0x\Api\platform\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group STM32F1xx_HAL_Driver
    ../Libraries/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_dma.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_i2c.c
  group VL53L0X
    ../User/vl53l0x/Api/core/src/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c
    ../User/vl53l0x/Api/platform/src/: vl53l0x_platform.c vl53l0x_i2c_rw.c
  group USER
    ../User/: main.c stm32f1xx_it.c board.c board.h
    ../User/dwt/: bsp_dwt.c
    ../User/led/: bsp_led.c
    ../User/usart/: bsp_usart.c
    ../User/i2c/: bsp_i2c.c
    ../User/vl53l0x/: bsp_i2c_vl53l0x.c
  group APP
    ../APP/vl53l0x/: app_vl53l0x.c
  group DOC
    ../Doc/: readme.txt
